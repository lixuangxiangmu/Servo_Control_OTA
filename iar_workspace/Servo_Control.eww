<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\app\project\iar\Servo_Control.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\boot\project\iar\Servo_Control_boot.ewp</path>
    </project>
    <batchBuild />
</workspace>
