# IAR project Servo_Control_boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F103xC GD GD32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: GD32F10X_HD; USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: ..\..\chip\gd32f10x_standard\CMSIS; ..\..\chip\gd32f10x_standard\Device; ..\..\application; ..\..\bsp; ..\..\config; ..\..\device; ..\..\drivers\gd32; ..\..\services\ota_service; ..\..\services\protocol_service; ..\..\middleware\utils; ..\..\components\storage\eeprom; ..\..\application\app_misc; ..\..\middleware\delay; ..\..\chip\gd32f10x_standard\GD32F10x_StdPeriph_Driver\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Servo_Control_boot.bin
  ILINK.IlinkOutputFile: Servo_Control_boot.out
  ILINK.IlinkIcfFile: linker\GD32F103xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: GD32F10X_HD; USE_STDPERIPH_DRIVER; NDEBUG
  ICCARM.CCIncludePath2: ..\..\chip\gd32f10x_standard\CMSIS; ..\..\chip\gd32f10x_standard\Device; ..\..\chip\gd32f10x_standard\GD32F10x_StdPeriph_Driver\Include; ..\..\application; ..\..\bsp; ..\..\config; ..\..\device; ..\..\drivers\gd32; ..\..\services\ota_service; ..\..\services\protocol_service; ..\..\middleware\utils; ..\..\components\storage\eeprom; ..\..\
  ICCARM.CCOptLevel: 3
  group Application
    ../../application/: app_main.c main.c
  group Application/app_misc
    ../../application/app_misc/: app_data_store.h app_mem_map.h
  group BSP
    ../../bsp/: board.c
  group Components
    ../../components/storage/eeprom/: eeprom.c
  group Config
    ../../config/: project_config.h
  group Device
    ../../device/: dev_flash.c dev_gpio.c dev_i2c.c dev_uart.c device.c
  group Drivers
    ../../drivers/gd32/: drv_flash.c drv_gpio.c drv_i2c.c drv_uart.c
  group GD32_Device
    ../../chip/gd32f10x_standard/Device/: gd32f10x_it.c system_gd32f10x.c
  group GD32_StdPeriph
    ../../chip/gd32f10x_standard/GD32F10x_StdPeriph_Driver/Source/: gd32f10x_dma.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_usart.c
  group Middleware
    ../../middleware/delay/: delay.c
    ../../middleware/utils/: utils_lib.c
  group Services/ota_servoces
    ../../services/ota_service/: ota_flash.c ota_image.c ota_protocol.c ota_service.c
  group Startup
    startup/: startup_gd32f10x_hd.s
