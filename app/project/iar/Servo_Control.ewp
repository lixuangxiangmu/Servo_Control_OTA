# IAR project Servo_Control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F103xC GD GD32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: GD32F10X_HD; USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: ..\..\application; ..\..\bsp; ..\..\config; ..\..\device; ..\..\drivers; ..\..\drivers\gd32; ..\..\services; ..\..\services\encoder_service; ..\..\services\fault_service; ..\..\services\key_service; ..\..\services\led_service; ..\..\services\ota_service; ..\..\services\remote_service; ..\..\services\servo_service; ..\..\services\watchdog_service; ..\..\components; ..\..\chip\gd32f10x_standard\CMSIS; ..\..\chip\gd32f10x_standard\Device; ..\..\chip\gd32f10x_standard\GD32F10x_StdPeriph_Driver\Include; ..\..\kernel\freertos; ..\..\kernel\freertos\Include; ..\..\kernel\freertos\portable\IAR\ARM_CM3; ..\..\services\comm_service; ..\..\application\app_misc; ..\..\components\storage\eeprom; ..\..\services\digital_tube_service; ..\..\middleware\utils
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\config
  OBJCOPY.OOCOutputFile: Servo_Control.bin
  ILINK.IlinkOutputFile: Servo_Control.out
  ILINK.IlinkKeepSymbols: .boot
  ILINK.IlinkIcfFile: ..\iar\linker\GD32F103xC.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../../application/: app_config.c app_control.c app_display.c app_hmi.c app_hw.c app_main.c app_state.c app_storage.c main.c
  group BSP
    ../../bsp/: board.c board_config.h
  group Chip/Device
    ../../chip/gd32f10x_standard/Device/: gd32f10x_it.c gd32f10x_libopt.h system_gd32f10x.c
  group Chip/GD32F10x_driver
    ../../chip/gd32f10x_standard/GD32F10x_StdPeriph_Driver/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Components
    ../../components/: README.md
  group Components/display/digital_tube
    ../../components/display/digital_tube/: digital_tube.c digital_tube.h
  group Components/storage
    ../../components/storage/eeprom/: eeprom.c
  group Config
    ../../config/: error_code.h feature_config.h FreeRTOSConfig.h project_config.h return_code.h version_config.h
  group Device
    ../../device/: dev_adc.c dev_gpio.c dev_i2c.c dev_pwm.c dev_timer.c dev_uart.c device.c
  group Drivers
    ../../drivers/gd32/: drv_adc.c drv_gpio.c drv_i2c.c drv_pwm.c drv_timer.c drv_uart.c
  group Kernel/FreeRTOS
    ../../kernel/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../kernel/freertos/portable/MemMang/: heap_4.c
    ../../kernel/freertos/portable/IAR/ARM_CM3/: port.c portasm.s
  group middleware/utils
    ../../middleware/utils/: utils_lib.c
  group Services
    ../../services/: services.c
  group Services/digital_tube_service
    ../../services/digital_tube_service/: digital_tube_service.c
  group Services/encoder_service
    ../../services/encoder_service/: encoder_service.c
  group Services/fault_service
    ../../services/fault_service/: fault_service.c
  group Services/key_service
    ../../services/key_service/: key_service.c
  group Services/led_service
    ../../services/led_service/: led_service.c
  group Services/ota_service
    ../../services/ota_service/: ota_image.c ota_protocol.c ota_service.c
  group Services/remote_service
    ../../services/remote_service/: remote_service.c
  group Services/servo_service
    ../../services/servo_service/: servo_service.c
  group Services/watchdog_service
    ../../services/watchdog_service/: watchdog_service.c
  group Startup
    startup/: startup_gd32f10x_hd.s
